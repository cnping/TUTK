# Keil uVision project gs2wifi.uvproj, settings and files
target gs2wifi (MCS-51)
  device: DP80390 Digital Core Design
  cpu: IRAM(0-0xFF) CLOCK(50000000) MOD_CONT MODDP2
  output: gs2w +hex
  AfterMake: ..\hexbin gs2w.hex
  AfterMake: ..\makeruntime8020 gs2w.bin r2w.bin
  c flags: Optimize=8 SizeSpeed=1
  c define: RuntimeCodeAt32KH
  c include: ..\src\main;..\src\mcpu;..\src\mswdma;..\src\uart0;..\src\mmstimer;..\src\mwif;..\src\madapter;..\src\mtcpip;..\src\mping;..\src\mpppoe;..\src\si2c;..\src\mdnsc;..\src\mconsole;..\src\mtelnet;..\src\meeprom;..\src\mmac;..\src\mdhcpc;..\src\mhttp;..\src\mgs2wifi;..\src\mhsuart;..\src\msmtpc;..\src\web_page;..\src\mdhcps;..\src\mdebug
  asm define: RuntimeCodeAt32KH
  asm include: ..\src\madapter;..\src\main;..\src\mconsole;..\src\mcpu;..\src\mdebug;..\src\mdhcpc;..\src\mdnsc;..\src\meeprom;..\src\mmac;..\src\mgs2wifi;..\src\mhsuart;..\src\mhttp;..\src\mmstimer;..\src\mping;..\src\mpppoe;..\src\msmtpc;..\src\mswdma;..\src\mtcpip;..\src\mtelnet;..\src\mwif;..\src\si2c;..\src\uart0;..\src\web_page;..\src\dhcps
  link misc: NOOVERLAY
  group mcpu
    ../src/mcpu/: interrupt.c mcpu.c START390.A51
  group main
    ../src/main/: main.c
  group mswdma
    ../src/mswdma/: dma.c
  group mwif
    ../src/mwif/: mpsave.c mwif.c mwioctl.c mwifapp.c
  group mtcpip
    ../src/mtcpip/: tcpip2.LIB uip.c uip_arch.c uip_arp.c
  group mping
    ../src/mping/: ping.c
  group mpppoe
    ../src/mpppoe/: pppoe.c
  group si2c
    ../src/si2c/: i2c.c
  group mdnsc
    ../src/mdnsc/: dnsc.c
  group mtelnet
    ../src/mtelnet/: telnet.c
  group mconsole
    ../src/mconsole/: clicmd.c console.c
  group madapter
    ../src/madapter/: adapter.c
  group mmac
    ../src/mmac/: mac.c phy.c stoe.c
  group uart0
    ../src/uart0/: uart0.c
  group mhttp
    ../src/mhttp/: httpd.c httpdapi.c
  group mweb_page
    ../src/web_page/: filesys.c filesys_1.c filesys_2.c filesys_3.c httpdap.c web_fun_act.c
  group mgs2wifi
    ../src/mgs2wifi/: gconfig.c gevent.c gtcpdat.c gudpbc.c gudpdat.c gudpmc.c gudpuc.c gs2w.c
  group mhsuart
    ../src/mhsuart/: hsuart2.c
  group msmtpc
    ../src/msmtpc/: CMIME64.c smtpc.c
  group mmstimer
    ../src/mmstimer/: mstimer.c delay.c
  group mdhcpc
    ../src/mdhcpc/: dhcpc.c
  group mdhcps
    ../src/mdhcps/: dhcps.c
  group mdebug
    ../src/mdebug/: printd.c
  group meeprom
    ../src/meeprom/: at24c02.c
  group iotc
    Y:/Lib/ASIX8051_220/: IOTCAPIs.lib
